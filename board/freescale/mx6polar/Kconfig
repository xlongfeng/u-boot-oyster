## board/freescale/mx6polar/Kconfig
```kconfig
if TARGET_MX6POLAR

config SYS_BOARD
	default "mx6polar"

config SYS_VENDOR
	default "freescale"

config SYS_CONFIG_NAME
	default "mx6polar"

endif
```
